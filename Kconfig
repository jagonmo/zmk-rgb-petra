## dts/bindings/behaviors/zmk,behavior-rgb-petra.yaml
```yaml
description: Petra RGB control behavior

compatible: "zmk,behavior-rgb-petra"

include: two_param.yaml
```
